Commit message: change robot geometry for sim

File: src/vehicle_simulator/urdf/robot.urdf.xacro (robot description, xacro)
@@ -8,4 +8,7 @@
     <visual>
       <origin xyz="0 0 0" rpy="0 0 0"/>
+      <geometry>
+        <box size="0.01 0.01 0.01"/>
+      </geometry>
     </visual>
   </link>
